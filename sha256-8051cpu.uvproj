# Keil uVision project sha256-8051cpu.uvproj, settings and files
target debug (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: sha256-8051cpu +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: STARTUP.A51 sha256.c test.c
